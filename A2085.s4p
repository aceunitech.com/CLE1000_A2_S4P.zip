!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:40:43
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S31: -52.9, -72.1, -59.2, -62.1, -45.2
!     S21: -1.2, -68.6, -62.9, -62.0, -55.4
!     S34: -1.2, -70.5, -60.7, -58.3, -56.2
!     S43: -1.2, -81.8, -64.6, -53.7, -59.5
!     S32: -53.7, -67.3, -61.3, -54.8, -65.2
!     S24: -48.1, -76.7, -58.3, -58.5, -47.5
!   lowest |S11| = -45.0 dB at 13.58 GHz (marker M1), VSWR 1.01, Z = 50.3 - j0.494 ohm
!   |S11| at or under -10 dB: 348.3 MHz to 27.97 GHz (27.62 GHz wide, 195 % of centre); 31.36 GHz to 38.81 GHz (7.447 GHz wide, 21.2 % of centre); 45.75 GHz to 51.33 GHz (5.575 GHz wide, 11.5 % of centre) (the widest 3 of 32)
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! magnitudes (dB):
! f  S11  S31  S21  S34  S43  S32  S24
! 10 MHz  -17.4  -52.9  -1.2  -1.2  -1.2  -53.7  -48.1
! 3.862 GHz  -14.6  -50.8  -33.3  -33.7  -33.6  -63.2  -85.8
! 13.58 GHz  -45.0  -58.4  -71.3  -70.3  -73.9  -74.3  -74.9
! 22.28 GHz  -16.1  -72.4  -75.6  -75.2  -82.1  -70.3  -72.8
! 34.51 GHz  -11.9  -49.6  -59.5  -55.1  -56.0  -60.3  -60.4
! 46.4 GHz  -12.9  -65.3  -60.1  -55.6  -58.8  -65.6  -50.3
! 67 GHz  -8.3  -45.2  -55.4  -56.2  -59.5  -65.2  -47.5

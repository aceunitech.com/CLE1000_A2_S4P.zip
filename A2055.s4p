!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:38:35
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S31: -54.1, -64.9, -50.1, -50.4, -46.3
!     S21: -0.8, -76.6, -54.1, -53.6, -53.3
!     S43: -0.9, -76.4, -66.6, -52.7, -57.8
!     S32: -47.3, -74.6, -58.3, -54.3, -49.1
!     S14: -47.4, -70.3, -63.4, -55.6, -64.1
!     S41: -46.5, -74.0, -59.3, -57.1, -54.2
!   lowest |S11| = -39.5 dB at 16.26 GHz (marker M1), VSWR 1.02, Z = 49.8 + j1.04 ohm
!   |S11| at or under -10 dB: 489.6 MHz to 27.95 GHz (27.46 GHz wide, 193 % of centre); 31.34 GHz to 38.78 GHz (7.444 GHz wide, 21.2 % of centre); 45.74 GHz to 51.32 GHz (5.578 GHz wide, 11.5 % of centre) (the widest 3 of 32)
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! magnitudes (dB):
! f  S11  S31  S21  S43  S32  S14  S41
! 10 MHz  -21.4  -54.1  -0.8  -0.9  -47.3  -47.4  -46.5
! 3.862 GHz  -14.8  -47.4  -23.2  -24.1  -57.6  -58.4  -59.3
! 16.26 GHz  -39.5  -61.2  -69.7  -69.2  -70.7  -89.1  -72.7
! 25.63 GHz  -12.0  -73.1  -68.8  -67.6  -65.7  -80.7  -66.6
! 41.71 GHz  -8.6  -49.9  -48.8  -49.7  -52.6  -53.0  -53.6
! 48.91 GHz  -23.1  -55.3  -58.3  -55.7  -77.6  -55.2  -60.3
! 67 GHz  -8.3  -46.3  -53.3  -57.8  -49.1  -64.1  -54.2

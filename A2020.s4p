!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:35:26
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S21: -0.2, -47.5, -66.5, -52.5, -58.6
!     S31: -54.2, -63.2, -48.7, -58.2, -49.6
!     S43: -0.2, -47.1, -63.8, -55.8, -49.2
!     S32: -57.9, -72.2, -64.5, -53.0, -56.5
!     S41: -57.0, -71.8, -55.1, -64.6, -50.7
!     S42: -62.3, -69.2, -56.6, -68.1, -49.7
!   lowest |S11| = -35.9 dB at 10.56 GHz (marker M1), VSWR 1.03, Z = 50.9 - j1.37 ohm
!   |S11| at or under -10 dB: 920.5 MHz to 27.94 GHz (27.02 GHz wide, 187 % of centre); 31.33 GHz to 38.8 GHz (7.468 GHz wide, 21.3 % of centre); 45.75 GHz to 51.32 GHz (5.569 GHz wide, 11.5 % of centre) (the widest 3 of 33)
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! magnitudes (dB):
! f  S11  S21  S31  S43  S32  S41  S42
! 10 MHz  -32.6  -0.2  -54.2  -0.2  -57.9  -57.0  -62.3
! 679.9 MHz  -22.9  -2.3  -52.9  -2.3  -49.1  -51.2  -54.3
! 10.56 GHz  -35.9  -24.7  -58.0  -25.0  -62.8  -62.5  -58.8
! 22.12 GHz  -21.2  -75.3  -66.0  -74.6  -70.7  -70.7  -70.8
! 41.54 GHz  -9.5  -76.6  -50.6  -65.2  -56.4  -51.5  -56.6
! 48.91 GHz  -23.4  -49.5  -49.2  -57.6  -51.4  -48.3  -55.8
! 67 GHz  -8.2  -58.6  -49.6  -49.2  -56.5  -50.7  -49.7

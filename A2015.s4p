!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:35:15
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S21: -0.2, -41.8, -55.0, -58.6, -51.7
!     S31: -47.5, -70.8, -55.9, -48.7, -43.9
!     S34: -0.1, -41.4, -66.4, -55.1, -56.4
!     S43: -0.1, -41.4, -55.8, -69.9, -55.5
!     S32: -52.0, -68.7, -65.5, -59.3, -50.7
!     S41: -50.9, -72.5, -69.3, -60.8, -61.8
!   lowest |S11| = -41.1 dB at 11.23 GHz (marker M1), VSWR 1.02, Z = 49.9 - j0.872 ohm
!   |S11| at or under -10 dB: 887.1 MHz to 27.95 GHz (27.06 GHz wide, 188 % of centre); 31.33 GHz to 38.76 GHz (7.427 GHz wide, 21.2 % of centre); 45.75 GHz to 51.32 GHz (5.572 GHz wide, 11.5 % of centre) (the widest 3 of 33)
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! magnitudes (dB):
! f  S11  S21  S31  S34  S43  S32  S41
! 10 MHz  -30.4  -0.2  -47.5  -0.1  -0.1  -52.0  -50.9
! 1.182 GHz  -23.6  -2.7  -50.2  -2.7  -2.7  -48.4  -48.4
! 11.23 GHz  -41.1  -22.1  -64.5  -22.2  -22.3  -53.6  -56.6
! 20.78 GHz  -17.7  -71.7  -69.3  -70.8  -73.2  -71.9  -67.8
! 24.96 GHz  -14.6  -76.8  -73.5  -68.8  -75.4  -72.0  -76.6
! 32.84 GHz  -12.0  -53.5  -51.8  -57.4  -63.9  -59.4  -59.3
! 67 GHz  -8.3  -51.7  -43.9  -56.4  -55.5  -50.7  -61.8

!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:38:47
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S31: -46.9, -76.4, -51.7, -51.9, -45.6
!     S21: -0.8, -66.0, -53.7, -57.3, -78.3
!     S34: -1.0, -81.3, -54.9, -54.6, -53.2
!     S43: -1.0, -79.8, -62.7, -64.7, -49.2
!     S32: -49.1, -71.9, -55.6, -59.9, -53.7
!     S41: -51.8, -72.9, -60.2, -58.7, -60.1
!   lowest |S11| = -38.4 dB at 10.9 GHz (marker M1), VSWR 1.02, Z = 50.5 - j1.09 ohm
!   |S11| at or under -10 dB: 432.9 MHz to 27.92 GHz (27.49 GHz wide, 194 % of centre); 32.18 GHz to 38.83 GHz (6.649 GHz wide, 18.7 % of centre); 45.75 GHz to 51.33 GHz (5.577 GHz wide, 11.5 % of centre) (the widest 3 of 32)
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! magnitudes (dB):
! f  S11  S31  S21  S34  S43  S32  S41
! 10 MHz  -20.6  -46.9  -0.8  -1.0  -1.0  -49.1  -51.8
! 4.197 GHz  -15.3  -48.2  -26.5  -27.3  -27.2  -61.1  -61.9
! 10.9 GHz  -38.4  -65.6  -55.8  -56.9  -56.9  -72.9  -65.7
! 16.92 GHz  -22.3  -63.7  -69.1  -77.2  -72.0  -70.4  -77.7
! 39.03 GHz  -10.5  -52.4  -58.3  -61.2  -52.4  -52.7  -51.5
! 55.44 GHz  -13.6  -49.2  -49.3  -53.5  -55.7  -54.6  -57.2
! 67 GHz  -8.3  -45.6  -78.3  -53.2  -49.2  -53.7  -60.1

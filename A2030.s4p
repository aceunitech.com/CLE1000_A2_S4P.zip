!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:36:13
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S31: -51.2, -63.2, -59.0, -63.7, -46.8
!     S21: -0.4, -63.4, -52.1, -50.5, -46.4
!     S43: -0.4, -70.3, -55.2, -84.5, -53.6
!     S32: -53.0, -74.1, -66.6, -52.2, -57.3
!     S41: -56.3, -73.2, -62.1, -48.3, -51.0
!     S42: -61.2, -72.1, -57.3, -57.8, -71.9
!   lowest |S11| = -34.6 dB at 13.74 GHz (marker M1), VSWR 1.04, Z = 50.5 + j1.81 ohm
!   |S11| at or under -10 dB: 867.2 MHz to 27.9 GHz (27.03 GHz wide, 188 % of centre); 32.18 GHz to 38.79 GHz (6.612 GHz wide, 18.6 % of centre); 45.76 GHz to 51.32 GHz (5.565 GHz wide, 11.5 % of centre) (the widest 3 of 34)
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! magnitudes (dB):
! f  S11  S31  S21  S43  S32  S41  S42
! 10 MHz  -31.2  -51.2  -0.4  -0.4  -53.0  -56.3  -61.2
! 5.369 GHz  -16.6  -46.6  -17.9  -18.9  -51.5  -54.7  -72.1
! 13.74 GHz  -34.6  -53.9  -45.3  -46.9  -80.1  -75.4  -72.8
! 21.61 GHz  -20.7  -62.7  -72.7  -92.5  -83.9  -69.8  -71.7
! 41.88 GHz  -8.9  -56.7  -52.4  -55.1  -69.2  -57.3  -54.6
! 48.91 GHz  -23.0  -47.3  -58.2  -65.0  -48.8  -59.1  -56.2
! 67 GHz  -8.3  -46.8  -46.4  -53.6  -57.3  -51.0  -71.9

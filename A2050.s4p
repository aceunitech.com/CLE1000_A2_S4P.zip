!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:38:01
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S31: -50.2, -63.1, -65.7, -54.5, -44.7
!     S21: -0.7, -77.5, -52.6, -52.2, -55.6
!     S43: -0.8, -78.1, -61.4, -61.2, -64.3
!     S32: -61.3, -70.3, -63.1, -53.0, -45.9
!     S41: -52.2, -81.1, -66.5, -53.4, -49.8
!     S24: -50.7, -81.5, -60.6, -66.7, -49.9
!   lowest |S11| = -42.7 dB at 11.23 GHz (marker M1), VSWR 1.01, Z = 50.5 + j0.518 ohm
!   |S11| at or under -10 dB: 547.4 MHz to 27.96 GHz (27.41 GHz wide, 192 % of centre); 31.35 GHz to 38.81 GHz (7.461 GHz wide, 21.3 % of centre); 45.75 GHz to 51.31 GHz (5.559 GHz wide, 11.5 % of centre) (the widest 3 of 32)
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! magnitudes (dB):
! f  S11  S31  S21  S43  S32  S41  S24
! 10 MHz  -23.1  -50.2  -0.7  -0.8  -61.3  -52.2  -50.7
! 4.197 GHz  -18.7  -47.5  -22.6  -23.8  -60.0  -58.2  -79.2
! 11.23 GHz  -42.7  -67.5  -52.5  -54.3  -68.9  -69.2  -67.9
! 19.44 GHz  -25.3  -64.0  -71.9  -84.3  -78.8  -77.9  -71.7
! 22.28 GHz  -19.4  -65.6  -79.2  -73.0  -69.1  -78.4  -77.8
! 35.01 GHz  -14.1  -51.4  -53.0  -55.2  -60.2  -76.9  -67.3
! 67 GHz  -8.3  -44.7  -55.6  -64.3  -45.9  -49.8  -49.9

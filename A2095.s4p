!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:41:22
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S31: -51.0, -66.6, -59.3, -51.7, -49.4
!     S21: -1.3, -68.5, -61.1, -62.3, -56.1
!     S43: -1.3, -68.3, -63.3, -57.1, -50.5
!     S32: -55.3, -72.0, -57.4, -60.7, -59.3
!     S41: -51.2, -79.8, -71.6, -56.4, -54.2
!     S24: -48.5, -88.2, -66.2, -55.4, -50.5
!   lowest |S11| = -35.1 dB at 19.6 GHz (marker M1), VSWR 1.04, Z = 48.9 - j1.32 ohm
!   |S11| at or under -10 dB: start of sweep to 27.88 GHz; 30.64 GHz to 38.71 GHz (8.079 GHz wide, 23.3 % of centre); 45.74 GHz to 51.31 GHz (5.568 GHz wide, 11.5 % of centre) (the widest 3 of 30)
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! magnitudes (dB):
! f  S11  S31  S21  S43  S32  S41  S24
! 10 MHz  -16.3  -51.0  -1.3  -1.3  -55.3  -51.2  -48.5
! 3.36 GHz  -21.0  -56.3  -32.9  -33.1  -63.5  -64.8  -72.3
! 8.551 GHz  -21.1  -51.6  -66.9  -63.0  -74.6  -69.4  -78.0
! 19.6 GHz  -35.1  -64.3  -72.7  -76.2  -67.8  -77.4  -74.2
! 22.28 GHz  -17.5  -74.5  -70.1  -76.7  -72.8  -72.5  -77.2
! 27.64 GHz  -11.8  -66.1  -64.1  -58.7  -61.0  -67.2  -62.3
! 67 GHz  -8.3  -49.4  -56.1  -50.5  -59.3  -54.2  -50.5

!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:36:01
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S21: -0.3, -55.8, -54.5, -55.6, -53.8
!     S31: -52.7, -63.9, -53.6, -54.0, -47.2
!     S43: -0.3, -59.7, -58.4, -57.3, -54.6
!     S32: -46.8, -74.2, -55.1, -49.1, -56.6
!     S41: -48.5, -73.2, -55.7, -63.7, -55.9
!     S42: -57.9, -68.2, -70.0, -53.0, -49.3
!   lowest |S11| = -41.2 dB at 15.42 GHz (marker M1), VSWR 1.02, Z = 49.2 - j0.403 ohm
!   |S11| at or under -10 dB: 904.4 MHz to 27.91 GHz (27.01 GHz wide, 187 % of centre); 30.62 GHz to 38.8 GHz (8.179 GHz wide, 23.6 % of centre); 45.75 GHz to 51.32 GHz (5.571 GHz wide, 11.5 % of centre) (the widest 3 of 32)
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! magnitudes (dB):
! f  S11  S21  S31  S43  S32  S41  S42
! 10 MHz  -33.9  -0.3  -52.7  -0.3  -46.8  -48.5  -57.9
! 679.9 MHz  -19.0  -3.1  -50.3  -3.3  -48.9  -50.8  -54.5
! 7.546 GHz  -17.7  -21.5  -46.9  -22.5  -53.6  -55.6  -74.2
! 15.42 GHz  -41.2  -47.2  -60.6  -48.7  -76.4  -70.5  -80.5
! 20.27 GHz  -23.4  -74.2  -77.4  -79.6  -72.6  -80.3  -77.1
! 43.22 GHz  -7.9  -65.6  -50.9  -75.4  -49.9  -56.8  -59.0
! 67 GHz  -8.4  -53.8  -47.2  -54.6  -56.6  -55.9  -49.3

!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:40:03
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S31: -52.2, -61.6, -56.2, -50.5, -46.1
!     S21: -1.0, -75.0, -52.4, -48.5, -49.4
!     S34: -1.1, -78.3, -62.3, -53.6, -56.0
!     S43: -1.1, -76.2, -57.5, -51.1, -55.7
!     S32: -52.8, -73.0, -61.9, -61.8, -49.2
!     S41: -55.5, -71.3, -65.8, -54.9, -55.8
!   lowest |S11| = -40.1 dB at 15.42 GHz (marker M1), VSWR 1.02, Z = 49.6 - j0.904 ohm
!   |S11| at or under -10 dB: 880.8 MHz to 27.92 GHz (27.03 GHz wide, 188 % of centre); 32.19 GHz to 38.8 GHz (6.616 GHz wide, 18.6 % of centre); 45.76 GHz to 51.32 GHz (5.563 GHz wide, 11.5 % of centre) (the widest 3 of 33)
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! magnitudes (dB):
! f  S11  S31  S21  S34  S43  S32  S41
! 10 MHz  -18.9  -52.2  -1.0  -1.1  -1.1  -52.8  -55.5
! 3.527 GHz  -17.1  -63.2  -27.3  -27.6  -27.7  -59.4  -60.4
! 15.42 GHz  -40.1  -61.6  -67.6  -74.1  -70.1  -86.6  -94.4
! 26.14 GHz  -12.3  -69.3  -66.7  -69.9  -75.7  -84.8  -65.5
! 36.02 GHz  -14.6  -50.8  -51.1  -55.1  -56.5  -51.9  -65.0
! 48.91 GHz  -22.5  -60.6  -67.6  -52.0  -50.4  -55.8  -54.3
! 67 GHz  -8.2  -46.1  -49.4  -56.0  -55.7  -49.2  -55.8

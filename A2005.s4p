!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:34:25
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S21: -0.1, -31.6, -59.6, -58.6, -45.0
!     S31: -53.4, -58.2, -65.3, -60.3, -45.2
!     S43: -0.1, -30.7, -63.8, -64.3, -65.0
!     S32: -55.6, -67.5, -53.6, -58.3, -56.6
!     S41: -61.3, -69.0, -55.7, -54.1, -44.8
!     S42: -48.7, -62.0, -74.2, -56.9, -55.3
!   lowest |S11| = -35.0 dB at 10.56 GHz (marker M1), VSWR 1.04, Z = 51.7 + j0.559 ohm
!   |S11| at or under -10 dB: 1.523 GHz to 27.97 GHz (26.45 GHz wide, 179 % of centre); 30.56 GHz to 38.77 GHz (8.205 GHz wide, 23.7 % of centre); 45.75 GHz to 51.33 GHz (5.575 GHz wide, 11.5 % of centre) (the widest 3 of 31)
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! magnitudes (dB):
! f  S11  S21  S31  S43  S32  S41  S42
! 10 MHz  -28.4  -0.1  -53.4  -0.1  -55.6  -61.3  -48.7
! 3.025 GHz  -15.4  -4.6  -46.5  -4.5  -41.2  -40.6  -51.0
! 10.56 GHz  -35.0  -15.4  -55.3  -15.1  -46.5  -47.2  -51.5
! 22.45 GHz  -18.1  -65.0  -66.1  -66.5  -73.8  -84.9  -74.0
! 24.13 GHz  -15.8  -64.8  -61.9  -65.8  -76.4  -76.2  -76.3
! 38.36 GHz  -12.9  -54.4  -59.1  -51.6  -66.2  -59.5  -58.0
! 67 GHz  -8.3  -45.0  -45.2  -65.0  -56.6  -44.8  -55.3

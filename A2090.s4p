!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:40:52
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S31: -42.3, -69.4, -58.4, -46.8, -47.8
!     S21: -1.2, -71.3, -56.0, -64.1, -48.4
!     S43: -1.2, -74.3, -60.1, -60.4, -50.0
!     S32: -47.9, -69.5, -65.3, -56.6, -49.7
!     S24: -52.7, -71.1, -58.8, -62.1, -61.6
!     S41: -44.2, -71.8, -58.0, -53.5, -63.9
!   lowest |S11| = -36.8 dB at 20.44 GHz (marker M1), VSWR 1.03, Z = 48.7 - j0.625 ohm
!   |S11| at or under -10 dB: start of sweep to 27.93 GHz; 32.2 GHz to 38.81 GHz (6.614 GHz wide, 18.6 % of centre); 45.06 GHz to 51.31 GHz (6.251 GHz wide, 13 % of centre) (the widest 3 of 30)
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! magnitudes (dB):
! f  S11  S31  S21  S43  S32  S24  S41
! 10 MHz  -16.9  -42.3  -1.2  -1.2  -47.9  -52.7  -44.2
! 2.355 GHz  -17.7  -53.5  -23.7  -23.8  -59.3  -65.9  -62.2
! 9.221 GHz  -21.9  -73.8  -63.9  -66.9  -87.6  -72.0  -72.4
! 20.44 GHz  -36.8  -68.0  -73.7  -67.5  -68.1  -67.6  -69.3
! 27.14 GHz  -10.0  -65.4  -68.5  -66.0  -77.7  -63.9  -68.3
! 54.27 GHz  -15.6  -42.8  -50.4  -51.9  -55.6  -54.8  -67.1
! 67 GHz  -8.2  -47.8  -48.4  -50.0  -49.7  -61.6  -63.9

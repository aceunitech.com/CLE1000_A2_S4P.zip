!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:39:25
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S31: -48.1, -62.0, -47.8, -50.2, -46.0
!     S21: -0.9, -82.9, -57.9, -50.6, -48.9
!     S34: -1.0, -70.3, -60.7, -52.7, -53.7
!     S43: -1.0, -84.8, -65.3, -56.1, -51.5
!     S32: -56.8, -71.6, -60.2, -55.3, -55.6
!     S41: -45.0, -75.3, -57.2, -63.4, -49.0
!   lowest |S11| = -32.6 dB at 47.91 GHz (marker M1), VSWR 1.05, Z = 51.4 + j1.95 ohm
!   |S11| at or under -10 dB: 867 MHz to 27.89 GHz (27.02 GHz wide, 188 % of centre); 31.34 GHz to 38.78 GHz (7.444 GHz wide, 21.2 % of centre); 45.75 GHz to 51.32 GHz (5.565 GHz wide, 11.5 % of centre) (the widest 3 of 33)
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! magnitudes (dB):
! f  S11  S31  S21  S34  S43  S32  S41
! 10 MHz  -20.0  -48.1  -0.9  -1.0  -1.0  -56.8  -45.0
! 3.694 GHz  -22.9  -53.0  -25.1  -25.8  -25.9  -57.4  -60.3
! 13.58 GHz  -23.5  -59.9  -79.1  -67.1  -73.5  -64.0  -85.4
! 22.28 GHz  -17.8  -71.4  -69.1  -72.8  -70.2  -69.8  -76.2
! 36.35 GHz  -12.6  -64.7  -45.9  -52.4  -58.7  -54.1  -55.8
! 47.91 GHz  -32.6  -52.4  -63.4  -61.6  -59.4  -54.1  -56.0
! 67 GHz  -8.3  -46.0  -48.9  -53.7  -51.5  -55.6  -49.0

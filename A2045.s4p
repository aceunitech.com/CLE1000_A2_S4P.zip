!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:37:50
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S31: -50.0, -64.6, -52.5, -53.7, -44.9
!     S21: -0.6, -77.2, -50.9, -51.1, -49.3
!     S34: -0.7, -70.3, -61.9, -60.9, -48.7
!     S43: -0.7, -74.9, -58.4, -63.3, -63.9
!     S32: -47.4, -67.9, -59.3, -52.5, -46.4
!     S41: -65.2, -84.2, -59.3, -53.6, -50.4
!   lowest |S11| = -41.2 dB at 14.58 GHz (marker M1), VSWR 1.02, Z = 49.3 + j0.492 ohm
!   |S11| at or under -10 dB: 574.7 MHz to 27.94 GHz (27.37 GHz wide, 192 % of centre); 32.18 GHz to 38.8 GHz (6.616 GHz wide, 18.6 % of centre); 45.75 GHz to 51.32 GHz (5.569 GHz wide, 11.5 % of centre) (the widest 3 of 32)
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! magnitudes (dB):
! f  S11  S31  S21  S34  S43  S32  S41
! 10 MHz  -24.4  -50.0  -0.6  -0.7  -0.7  -47.4  -65.2
! 5.537 GHz  -22.6  -51.4  -25.4  -26.8  -26.8  -55.2  -58.8
! 14.58 GHz  -41.2  -61.8  -66.4  -70.2  -70.7  -70.8  -77.0
! 22.45 GHz  -19.4  -64.3  -77.1  -76.2  -74.1  -70.7  -75.3
! 27.14 GHz  -10.1  -63.7  -59.9  -57.1  -71.5  -67.1  -63.7
! 48.91 GHz  -23.0  -50.1  -50.1  -59.0  -61.0  -48.1  -54.5
! 67 GHz  -8.2  -44.9  -49.3  -48.7  -63.9  -46.4  -50.4

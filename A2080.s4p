!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:40:16
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S31: -50.5, -63.0, -54.7, -66.1, -44.0
!     S21: -1.1, -67.8, -70.5, -63.1, -56.0
!     S43: -1.1, -70.4, -55.2, -58.5, -52.1
!     S32: -47.0, -79.5, -57.5, -54.4, -59.2
!     S41: -50.1, -81.1, -83.1, -57.2, -49.1
!     S42: -53.6, -75.7, -57.6, -69.7, -50.7
!   lowest |S11| = -38.0 dB at 14.58 GHz (marker M1), VSWR 1.03, Z = 51 + j0.817 ohm
!   |S11| at or under -10 dB: 867.7 MHz to 27.96 GHz (27.09 GHz wide, 188 % of centre); 30.64 GHz to 38.79 GHz (8.149 GHz wide, 23.5 % of centre); 45.74 GHz to 51.33 GHz (5.587 GHz wide, 11.5 % of centre) (the widest 3 of 31)
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! magnitudes (dB):
! f  S11  S31  S21  S43  S32  S41  S42
! 10 MHz  -17.9  -50.5  -1.1  -1.1  -47.0  -50.1  -53.6
! 4.532 GHz  -21.3  -66.0  -35.2  -35.3  -68.3  -68.2  -72.4
! 14.58 GHz  -38.0  -61.3  -86.7  -71.8  -71.5  -72.6  -77.3
! 34.34 GHz  -12.0  -52.8  -54.6  -63.1  -54.9  -63.4  -68.4
! 46.74 GHz  -13.8  -52.7  -49.7  -76.1  -61.7  -61.9  -59.1
! 48.91 GHz  -23.0  -44.0  -51.4  -59.7  -57.5  -57.4  -52.8
! 67 GHz  -8.2  -44.0  -56.0  -52.1  -59.2  -49.1  -50.7

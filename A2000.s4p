!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:33:37
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S43: -0.1, -14.1, -30.9, -46.6, -57.3
!     S21: -0.1, -14.2, -32.9, -50.4, -72.9
!     S31: -59.8, -54.4, -48.1, -52.5, -43.4
!     S32: -43.8, -48.5, -50.1, -54.1, -52.6
!     S41: -52.4, -49.3, -56.0, -65.9, -57.7
!     S42: -56.6, -64.6, -56.3, -51.7, -52.4
!   lowest |S11| = -45.9 dB at 17.09 GHz (marker M1), VSWR 1.01, Z = 49.5 - j0.0415 ohm
!   |S11| at or under -10 dB: start of sweep to 28.8 GHz; 32.17 GHz to 38.77 GHz (6.607 GHz wide, 18.6 % of centre); 45.75 GHz to 51.32 GHz (5.567 GHz wide, 11.5 % of centre) (the widest 3 of 31)
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! magnitudes (dB):
! f  S11  S43  S21  S31  S32  S41  S42
! 10 MHz  -26.9  -0.1  -0.1  -59.8  -43.8  -52.4  -56.6
! 4.364 GHz  -26.4  -3.2  -3.2  -46.3  -36.5  -36.1  -51.3
! 17.09 GHz  -45.9  -14.0  -14.2  -48.8  -50.7  -47.2  -49.0
! 22.12 GHz  -19.7  -23.7  -24.3  -46.3  -49.4  -48.0  -40.0
! 26.97 GHz  -12.0  -26.1  -26.0  -55.3  -51.2  -65.5  -65.3
! 58.46 GHz  -6.9  -57.0  -54.7  -57.1  -46.1  -55.8  -45.6
! 67 GHz  -8.3  -57.3  -72.9  -43.4  -52.6  -57.7  -52.4

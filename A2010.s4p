!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:34:40
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S21: -0.2, -37.4, -53.4, -51.8, -44.8
!     S43: -0.1, -37.1, -68.7, -60.9, -53.1
!     S31: -53.4, -61.5, -54.6, -62.1, -45.1
!     S32: -52.5, -67.0, -56.7, -47.7, -54.9
!     S41: -59.3, -79.9, -67.1, -56.1, -52.1
!     S42: -62.3, -85.8, -62.8, -55.8, -58.7
!   lowest |S11| = -39.5 dB at 4.197 GHz (marker M1), VSWR 1.02, Z = 50.5 + j0.936 ohm
!   |S11| at or under -10 dB: 1.531 GHz to 27.96 GHz (26.43 GHz wide, 179 % of centre); 30.58 GHz to 38.78 GHz (8.199 GHz wide, 23.6 % of centre); 45.75 GHz to 51.32 GHz (5.573 GHz wide, 11.5 % of centre) (the widest 3 of 31)
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! magnitudes (dB):
! f  S11  S21  S43  S31  S32  S41  S42
! 10 MHz  -29.1  -0.2  -0.1  -53.4  -52.5  -59.3  -62.3
! 4.197 GHz  -39.5  -7.2  -7.1  -49.3  -41.6  -40.9  -57.7
! 17.43 GHz  -18.5  -41.7  -41.7  -56.9  -67.2  -70.1  -70.8
! 22.28 GHz  -18.5  -76.7  -68.2  -61.1  -65.6  -82.1  -78.7
! 24.46 GHz  -14.4  -81.4  -70.7  -60.6  -65.0  -73.8  -80.2
! 48.91 GHz  -24.2  -61.6  -54.2  -56.8  -56.8  -52.6  -57.3
! 67 GHz  -8.3  -44.8  -53.1  -45.1  -54.9  -52.1  -58.7

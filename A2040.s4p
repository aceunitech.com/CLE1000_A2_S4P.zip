!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:37:16
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S21: -0.5, -64.6, -58.7, -69.1, -47.6
!     S31: -56.2, -67.7, -54.6, -54.1, -48.5
!     S43: -0.6, -68.9, -55.9, -57.0, -62.3
!     S32: -47.2, -70.3, -69.6, -56.2, -49.3
!     S41: -47.8, -78.0, -62.3, -58.0, -53.5
!     S42: -54.5, -73.4, -62.9, -57.5, -49.0
!   lowest |S11| = -34.2 dB at 11.4 GHz (marker M1), VSWR 1.04, Z = 48.2 - j0.759 ohm
!   |S11| at or under -10 dB: 582.5 MHz to 27.92 GHz (27.34 GHz wide, 192 % of centre); 30.63 GHz to 38.77 GHz (8.146 GHz wide, 23.5 % of centre); 45.76 GHz to 51.32 GHz (5.559 GHz wide, 11.5 % of centre) (the widest 3 of 31)
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! magnitudes (dB):
! f  S11  S21  S31  S43  S32  S41  S42
! 10 MHz  -26.3  -0.5  -56.2  -0.6  -47.2  -47.8  -54.5
! 6.876 GHz  -21.5  -27.8  -56.8  -29.2  -62.6  -58.6  -90.4
! 11.4 GHz  -34.2  -43.9  -65.6  -45.8  -74.4  -71.3  -72.1
! 21.78 GHz  -19.8  -73.7  -69.2  -75.2  -64.8  -65.5  -73.0
! 36.69 GHz  -12.9  -49.0  -53.9  -59.7  -59.1  -70.2  -60.4
! 65.49 GHz  -3.8  -56.5  -49.8  -61.0  -45.8  -52.7  -67.2
! 67 GHz  -8.2  -47.6  -48.5  -62.3  -49.3  -53.5  -49.0

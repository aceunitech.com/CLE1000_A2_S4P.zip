!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:37:03
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S21: -0.4, -64.7, -54.8, -56.3, -49.7
!     S31: -48.0, -63.4, -54.9, -57.6, -45.3
!     S43: -0.5, -63.5, -64.4, -55.6, -56.8
!     S14: -53.0, -78.3, -64.8, -49.6, -52.1
!     S32: -53.3, -78.4, -62.1, -54.1, -43.9
!     S41: -56.0, -70.6, -54.9, -54.9, -58.2
!   lowest |S11| = -42.2 dB at 17.93 GHz (marker M1), VSWR 1.02, Z = 50.6 + j0.549 ohm
!   |S11| at or under -10 dB: 576 MHz to 27.9 GHz (27.33 GHz wide, 192 % of centre); 31.34 GHz to 38.81 GHz (7.473 GHz wide, 21.3 % of centre); 45.75 GHz to 51.32 GHz (5.566 GHz wide, 11.5 % of centre) (the widest 3 of 32)
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! magnitudes (dB):
! f  S11  S21  S31  S43  S14  S32  S41
! 10 MHz  -28.6  -0.4  -48.0  -0.5  -53.0  -53.3  -56.0
! 4.867 GHz  -20.0  -18.3  -62.1  -19.3  -52.5  -51.1  -52.3
! 12.4 GHz  -17.8  -43.6  -55.3  -45.7  -65.1  -74.6  -65.5
! 17.93 GHz  -42.2  -64.2  -63.5  -66.9  -74.8  -74.9  -69.2
! 22.45 GHz  -17.6  -64.2  -66.6  -71.6  -86.3  -72.4  -71.2
! 27.64 GHz  -12.5  -88.3  -58.9  -63.2  -58.2  -62.2  -58.4
! 67 GHz  -8.2  -49.7  -45.3  -56.8  -52.1  -43.9  -58.2

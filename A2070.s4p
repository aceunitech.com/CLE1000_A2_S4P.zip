!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:39:36
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S31: -49.0, -70.6, -57.0, -54.3, -46.3
!     S21: -0.9, -70.6, -60.9, -51.9, -57.5
!     S34: -1.0, -79.8, -58.4, -54.3, -61.9
!     S43: -1.0, -74.4, -67.7, -56.8, -67.4
!     S32: -57.1, -66.8, -53.3, -55.6, -56.0
!     S41: -53.9, -74.6, -56.7, -57.2, -68.7
!   lowest |S11| = -38.3 dB at 10.73 GHz (marker M1), VSWR 1.02, Z = 50.7 - j0.987 ohm
!   |S11| at or under -10 dB: 884.9 MHz to 27.89 GHz (27.01 GHz wide, 188 % of centre); 31.36 GHz to 38.76 GHz (7.407 GHz wide, 21.1 % of centre); 45.75 GHz to 51.31 GHz (5.561 GHz wide, 11.5 % of centre) (the widest 3 of 34)
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! magnitudes (dB):
! f  S11  S31  S21  S34  S43  S32  S41
! 10 MHz  -19.6  -49.0  -0.9  -1.0  -1.0  -57.1  -53.9
! 3.527 GHz  -19.0  -59.1  -25.5  -26.0  -26.0  -57.0  -59.0
! 7.546 GHz  -22.6  -50.3  -47.3  -47.7  -47.7  -68.3  -81.6
! 10.73 GHz  -38.3  -68.5  -59.2  -59.0  -57.2  -64.8  -64.3
! 19.44 GHz  -26.9  -65.8  -71.6  -76.2  -79.5  -79.7  -86.2
! 37.36 GHz  -11.3  -50.8  -57.9  -51.0  -52.5  -54.6  -59.0
! 67 GHz  -8.3  -46.3  -57.5  -61.9  -67.4  -56.0  -68.7

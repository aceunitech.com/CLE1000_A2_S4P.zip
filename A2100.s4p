!Agilent Technologies,N5247A,US50470101,A.10.25.02
!Agilent N5247A: A.10.25.02
!Date: Friday, April 24, 2015 13:41:34
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   401 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S31: -58.0, -68.3, -51.2, -54.4, -43.2
!     S21: -1.4, -71.6, -60.4, -49.5, -45.1
!     S43: -1.4, -100.9, -57.8, -64.7, -57.9
!     S32: -54.4, -70.1, -56.0, -57.6, -47.3
!     S41: -46.4, -77.0, -58.2, -64.5, -55.4
!     S42: -41.9, -73.1, -65.1, -53.3, -46.1
!   lowest |S11| = -34.8 dB at 15.42 GHz (marker M1), VSWR 1.04, Z = 51.7 + j0.598 ohm
!   |S11| at or under -10 dB: start of sweep to 27.86 GHz; 31.36 GHz to 38.8 GHz (7.441 GHz wide, 21.2 % of centre); 45.06 GHz to 51.31 GHz (6.252 GHz wide, 13 % of centre) (the widest 3 of 30)
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! magnitudes (dB):
! f  S11  S31  S21  S43  S32  S41  S42
! 10 MHz  -15.6  -58.0  -1.4  -1.4  -54.4  -46.4  -41.9
! 2.522 GHz  -17.2  -50.4  -27.3  -27.2  -59.1  -58.0  -89.8
! 8.886 GHz  -20.8  -59.2  -78.2  -66.8  -70.0  -98.4  -75.5
! 15.42 GHz  -34.8  -63.7  -77.6  -81.1  -69.9  -73.8  -73.3
! 22.45 GHz  -20.1  -63.2  -71.1  -75.8  -66.1  -71.8  -79.1
! 27.64 GHz  -11.7  -64.0  -57.8  -71.0  -64.5  -67.4  -64.3
! 67 GHz  -8.3  -43.2  -45.1  -57.9  -47.3  -55.4  -46.1
